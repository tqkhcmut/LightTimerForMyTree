# IAR project UARTGateway.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5309 MSP430F5309
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\components\targets\trxeb_msp430f5438a; ..\components\bsp\trxeb_msp5438a\drivers\source; ..\components\targets\interface; ..\components\common; ..\components\common\msp430; ..\components\devices\cc120x; ..\components\devices\lcd_dogm128_6; ..\MSP430F5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5309.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: LEDs.c LEDs.h main.c main_rx.c relays.c relays.h rf_conf.c
  group bsp
    ../components/bsp/trxeb_msp5438a/drivers/source/: bsp.c bsp_uart.c io_pin_int.c
  group hal
    ../components/devices/cc120x/: cc120x_spi.c
    ../components/targets/trxeb_msp430f5438a/: hal_spi_rf_trxeb.c
  group Libraries
    ../MSP430F5xx_6xx/: adc10_a.c driverlib.h gpio.c gpio.h
