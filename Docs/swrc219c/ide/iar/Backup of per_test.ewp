# IAR project Backup of per_test.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MENU_ANIMATED
  ICC430.IExtraOptions: --diag_remark=Pe177
  ICC430.newCCIncludePaths: ..\..\source\components\targets\trxeb_msp430f5438a; ..\..\source\components\bsp\trxeb_msp5438a\drivers\source; ..\..\source\components\targets\interface; ..\..\source\components\common; ..\..\source\apps\per_test\radios; ..\..\source\apps\per_test\radios\cc1101; ..\..\source\apps\per_test\radios\cc11xL; ..\..\source\apps\per_test\radios\cc11xL\cc110L; ..\..\source\apps\per_test\radios\cc11xL\cc115L; ..\..\source\apps\per_test\radios\cc11xL\cc113L; ..\..\source\apps\per_test\radios\cc112x; ..\..\source\apps\per_test\radios\cc120x; ..\..\source\apps\per_test\radios\cc1101_cc1190; ..\..\source\apps\per_test\radios\cc1120_cc1190; ..\..\source\apps\per_test; ..\..\source\apps\sniff_mode; ..\..\source\apps\chip_information; ..\..\source\apps\simpleLink; ..\..\source\apps\simpleLink\cc1101; ..\..\source\apps\simpleLink\cc112x; ..\..\source\apps\easyLink; ..\..\source\apps\easyLink\cc120x_easy_link; ..\..\source\apps\easyLink\cc112x_easy_link; ..\..\source\apps\easyLink\cc1101_easy_link; ..\..\source\apps\easyLink\cc11xL_easy_link; ..\..\source\examples\menu_system; ..\..\source\components\common\msp430
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../source/apps/per_test/: main.c
  group bsp
    ../../source/components/bsp/trxeb_msp5438a/drivers/source/: als_trxeb.c bsp.c bsp_key.c bsp_led.c bsp_uart.c flash_trxeb.c io_pin_int.c lcd_dogm128_6.c lcd_dogm128_6_alphabet.c lcd_trxeb.c
  group chip_info
    ../../source/apps/chip_information/: chip_information.c
  group easyLink
    ../../source/apps/easyLink/: easyLink.c easyLink_gui.c
  group easyLink/cc1101_easy_link
    ../../source/apps/easyLink/cc1101_easy_link/: cc1101_easy_link_reg_config.h cc1101_easy_link_rx.c cc1101_easy_link_tx.c
  group easyLink/cc112x_easy_link
    ../../source/apps/easyLink/cc112x_easy_link/: cc112x_easy_link_reg_config.h cc112x_easy_link_rx.c cc112x_easy_link_tx.c
  group easyLink/cc11xL_easy_link
    ../../source/apps/easyLink/cc11xL_easy_link/: cc110L_easy_link_rx.c cc110L_easy_link_tx.c cc113L_easy_link_rx.c cc115L_easy_link_tx.c cc11xL_easy_link_reg_config.h
  group easyLink/cc120x_easy_link
    ../../source/apps/easyLink/cc120x_easy_link/: cc120x_easy_link_reg_config.h cc120x_easy_link_rx.c cc120x_easy_link_tx.c
  group hal
    ../../source/apps/per_test/radios/cc1101/: cc1101_spi.c
    ../../source/apps/per_test/radios/cc112x/: cc112x_spi.c
    ../../source/apps/per_test/radios/cc11xL/: cc11xL_spi.c
    ../../source/apps/per_test/radios/cc120x/: cc120x_spi.c
    ../../source/apps/per_test/: chip_detect.c freq_xosc_detect.c
    ../../source/components/targets/trxeb_msp430f5438a/: hal_timer_32k.c
    ../../source/apps/per_test/radios/: trx_rf_spi.c
  group menu_system
    ../../source/examples/menu_system/: menu_driver.c menu_system.c
  group per_test
    ../../source/apps/per_test/radios/cc1101_cc1190/: cc1101_cc1190_per_test_api.c
    ../../source/apps/per_test/radios/cc1101/: cc1101_per_test_api.c
    ../../source/apps/per_test/radios/cc11xL/cc110L/: cc110L_per_test_api.c
    ../../source/apps/per_test/radios/CC1120_CC1190/: cc1120_cc1190_per_test_api.c
    ../../source/apps/per_test/radios/cc112x/: cc112x_per_test_api.c
    ../../source/apps/per_test/radios/cc11xL/cc113L/: cc113L_per_test_api.c
    ../../source/apps/per_test/radios/cc11xL/cc115L/: cc115L_per_test_api.c
    ../../source/apps/per_test/radios/cc120x/: cc120x_per_test_api.c
    ../../source/apps/per_test/: hal_create_random.c per_test.c per_test_gui.c
  group sniff_mode
    ../../source/apps/sniff_mode/: cc112x_sniff_mode_api.c cc120x_sniff_mode_api .c sniff_mode.c sniff_mode_gui.c
